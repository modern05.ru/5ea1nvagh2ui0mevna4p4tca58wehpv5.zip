Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-01-17T08:36:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Alternate UI 19.2.50.16
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Jan 17 08:36:00 2023* Host: NCL-ManOps17* Database: C:\Users\bateyjo\AppData\Local\Temp\{8FFA966B-D164-495C-8A27-97F7C601B499}\ifc* Database version: 5507* Database creation date: Tue Jan 17 08:36:00 2023* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Jan 17 08:36:00 2023* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Jan 17 08:36:00 2023* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: UBQ180SQE2DV-01, NBS_VilleroyAndBochAG_Bths_SquaroEdge12_RectangularBath_UBQ180SQE2DV:UBQ180SQE2DV-01:419910
In: Level 0
Type - PredefinedType: BATH; Classification: Pr_40_20_06_08 (Uniclass2015); Material: NBS_VilleroyAndBoch_Chrome, NBS_VilleroyAndBoch_Quaryl_WhiteAlpin
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_Baths_SquaroEdge12_RectangularBathUBQ180SQE2DV_UBQ180SQE2DV-01; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/r0d1qmrf; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/UBQ180SQE2DV; Revision: 2; Uniclass2015Title: Baths; Uniclass2015Code: Pr_40_20_06_08; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - AntiSlipFinish: Class A; Approval: n/a; Colour: Alpin White, Stone White; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; Execution: n/a; Form: Rectangular; IntegralAccessories: Special Combipool Invisible, Matching outlet and overflow; Materials: Quaryl®; Recyclability: n/a; RecycledContent: n/a; Size: 1800 x 800 x 450 mm; Standards: n/a; SupportFrame: n/a; VolumeToOverflowMaximum: 180 L; WaterSupplyOverflowAndWasteHolesOverflow: Overflow hole; WaterSupplyOverflowAndWasteHolesWaste: Central waste outlet; WaterSupplyOverflowAndWasteHolesWaterSupply: No tap holes
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: BATH
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_06_08:Baths; CodePerformance: n/a; Color: White; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Gloss, Matt; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Quaryl®; ModelNumber: UBQ180SQE2DV-01; ModelReference: SquaroEdge12_RectangularBathUBQ180SQE2DV_UBQ180SQE2DV-01; Name: Baths_SquaroEdge12_RectangularBathUBQ180SQE2DV_UBQ180SQE2DV-01_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: Rectangle; Size: 1800 x 800 x 450 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
